# IAR project FingerprintSwitch.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G4 STM8L151G4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: STM8L15x_StdPeriph_Driver\inc; Code\Inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: FingerprintSwitch.hex
  ILINK.IlinkOutputFile: FingerprintSwitch.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD
  group APP
    Code/Src/: user.c
  group Beep
    Code/Src/: beep.c
  group Delay
    Code/Src/: delay.c
  group Fingerprint
    Code/Src/: finger.c
  group IWDG
    Code/Src/: iwdg.c
  group Lowpower
    Code/Src/: lowpower.c
  group Relay
    Code/Src/: relay.c
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group Switch
    Code/Src/: switch.c
  group Systick
    Code/Src/: systick.c
  group User
    Code/Src/: main.c stm8l15x_it.c
