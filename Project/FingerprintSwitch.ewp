# IAR project FingerprintSwitch.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; Code\Inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: FingerprintSwitch.hex
  ILINK.IlinkOutputFile: FingerprintSwitch.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S003
  group APP
    Code/Src/: main.c stm8s_it.c
  group Delay
    Code/Src/: delay.c
  group Fingerprint
    Code/Src/: finger.c
  group IWDG
    Code/Src/: iwdg.c
  group Lowpower
    Code/Src/: lowpower.c
  group Relay_Beep
    Code/Src/: relay_beep.c
  group StdPeriph_Drivers
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
  group Switch
    Code/Src/: switch.c
  group Systick
    Code/Src/: systick.c
  group User
    Code/Src/: user.c
